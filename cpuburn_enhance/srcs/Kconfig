## cpuburn_enhance/srcs/Kconfig
```kconfig
menu "cpuburn driver"
	config XXX_CPUBURN
		tristate "cpuburn"
		default n
	help
	cpuburn
endmenu
```
